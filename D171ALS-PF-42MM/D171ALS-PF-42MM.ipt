# Autodesk Inventor part: D171AEXS-PF-42MM
## iProperties
Created: 2011-11
Part Number: D171AEXS-PF-42MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
